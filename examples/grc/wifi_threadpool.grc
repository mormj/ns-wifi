options:
  parameters:
    author: josh
    generate_options: no_gui
    id: wifi_threadpool
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: nthreads
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: decode
  id: wifi_decode_packetized
  parameters:
    debug: 'False'
    domain: cpu
    log: 'False'
  states: {}
- name: domain_conf
  id: snippet
  parameters:
    code: |-
      nbtsched = nbt.scheduler_nbt("nbtsched")
      tpsched = threadpool.scheduler_threadpool("threadpool", num_threads=self.nthreads)
                
      self.add_scheduler(nbtsched)
      self.add_scheduler(tpsched)

      dconf = [ gr.domain_conf(nbtsched, [ self.src, self.pre_sync, self.sync_short, self.sync_long, self.fft_blk, self.packetize ]),
                gr.domain_conf(tpsched, [ self.decode ]) ]

      self.partition(dconf)
    section: main_after_init
  states: {}
- name: fft_blk
  id: fft_fft
  parameters:
    T: complex
    direction: 'True'
    domain: cuda
    fft_size: '64'
    shift: 'True'
    window: np.ones(64)
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from newsched.schedulers import nbt, threadpool
  states: {}
- name: packetize
  id: wifi_packetize_frame
  parameters:
    algo: '0'
    bw: 20e6
    debug: 'False'
    domain: cpu
    freq: 2462e6
    log: 'False'
  states: {}
- name: pre_sync
  id: wifi_pre_sync
  parameters:
    buffer_size: 1024*1024*2
    domain: cuda
    window_size: '48'
  states: {}
- name: src
  id: fileio_file_source
  parameters:
    domain: cpu
    filename: /data/data/wifi_capt_2462_20MHz.fc32
    itemsize: gr.sizeof_gr_complex
    len: '0'
    offset: '0'
    repeat: 'False'
  states: {}
- name: sync_long
  id: wifi_sync_long
  parameters:
    debug: 'False'
    domain: cuda
    log: 'False'
    sync_length: sync_length
  states: {}
- name: sync_short
  id: wifi_sync_short
  parameters:
    debug: 'False'
    domain: cuda
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}

connections:
- [fft_blk, '0', packetize, '0']
- [packetize, pdus, decode, pdus]
- [pre_sync, '0', sync_short, '0']
- [pre_sync, '1', sync_short, '1']
- [pre_sync, '2', sync_short, '2']
- [src, '0', pre_sync, '0']
- [sync_long, '0', fft_blk, '0']
- [sync_short, '0', sync_long, '0']

metadata:
  file_format: 1
